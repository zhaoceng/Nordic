# Keil uVision project Mesh_Project_Light.uvprojx, settings and files
target Project_Light (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mesh_Project_Light +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_APP_IN_CORE USE_APP_CONFIG NO_VTOR_CONFIG BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832 NRF52832_XXAA NRF52_SERIES NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=4096 DEBUG
  c include: ..\include;..\Mesh_SDK\common\include;..\Mesh_SDK\mesh\core\include;..\Mesh_SDK\mesh\stack\src;..\Mesh_SDK\mesh\stack\api;..\Mesh_SDK\mesh\gatt\include;..\Mesh_SDK\mesh\access\include;..\Mesh_SDK\mesh\bearer\include;..\Mesh_SDK\external\rtt\include;..\Mesh_SDK\external\micro-ecc;..\nRF52_SDK_15.2\components\libraries\pwm;..\nRF52_SDK_15.2\modules\nrfx\drivers\include;..\nRF52_SDK_15.2\integration\nrfx\legacy;..\nRF52_SDK_15.2\components\libraries\util;..\nRF52_SDK_15.2\components\ble\common;..\nRF52_SDK_15.2\components\libraries\experimental_section_vars;..\nRF52_SDK_15.2\components\softdevice\common;..\nRF52_SDK_15.2\components\libraries\atomic;..\nRF52_SDK_15.2\modules\nrfx\mdk;..\nRF52_SDK_15.2\components\libraries\util;..\nRF52_SDK_15.2\modules\nrfx\mdk;..\nRF52_SDK_15.2\modules\nrfx\drivers;..\nRF52_SDK_15.2\modules\nrfx\hal;..\nRF52_SDK_15.2\integration\nrfx;..\nRF52_SDK_15.2\integration\nrfx\legacy;..\Mesh_SDK\mesh\prov\include;..\Mesh_SDK\models\foundation\config\include;..\Mesh_SDK\models\foundation\health\include;..\Mesh_SDK\models\model_spec\generic_level\include;..\Mesh_SDK\models\model_spec\common\include;..\Mesh_SDK\external\app_timer;..\nRF52_SDK_15.2\components\softdevice\s132\headers;..\Mesh_SDK\mesh\gatt\api;..\Mesh_SDK\mesh\access\api;..\Mesh_SDK\mesh\bearer\api;..\Mesh_SDK\mesh\core\api;..\Mesh_SDK\mesh\stack\api;..\Mesh_SDK\mesh\prov\api;..\nRF52_SDK_15.2\components\boards;..\nRF52_SDK_15.2\modules\nrfx;..\nRF52_SDK_15.2\components\libraries\timer;..\Mesh_SDK\mesh\dfu\api;..\Mesh_SDK\mesh\dfu\include;..\nRF52_SDK_15.2\components\libraries\delay;..\nRF52_SDK_15.2\components\libraries\log;..\nRF52_SDK_15.2\components\libraries\strerror;..\nRF52_SDK_15.2\components\libraries\log\src;..\nRF52_SDK_15.2\components\libraries\mem_manager
  asm define: CONFIG_APP_IN_CORE USE_APP_CONFIG NO_VTOR_CONFIG BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832 NRF52832_XXAA NRF52_SERIES SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=4096
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x78000
  memory RVCT9: RAM 0x20002da0 size 0xf000
  group Application
    ../src/: main.c sha256.c
    ../Mesh_SDK/: nrf_mesh_weak.c
    ../Mesh_SDK/common/src/: app_error_weak.c app_level.c assertion_handler_weak.c ble_softdevice_support.c mesh_adv.c mesh_app_utils.c mesh_provisionee.c rtt_input.c
    ../include/: sdk_config.h
  group Core
    ../Mesh_SDK/mesh/core/src/: aes.c aes_cmac.c beacon.c bearer_event.c cache.c ccm_soft.c core_tx.c core_tx_adv.c core_tx_lpn.c enc.c event.c fifo.c flash_manager.c flash_manager_defrag.c flash_manager_internal.c fsm.c hal.c heartbeat.c internal_event.c list.c log.c lpn.c mesh_config.c mesh_config_backend.c mesh_config_flashman_glue.c mesh_flash.c mesh_lpn_subman.c mesh_mem_stdlib.c mesh_opt.c msg_cache.c msqueue.c net_beacon.c net_packet.c net_state.c network.c nrf_flash.c nrf_mesh.c nrf_mesh_configure.c nrf_mesh_keygen.c nrf_mesh_opt.c nrf_mesh_utils.c packet_buffer.c queue.c replay_cache.c timer.c timer_scheduler.c timeslot.c timeslot_timer.c toolchain.c transport.c rand.c
  group Mesh Stack
    ../Mesh_SDK/mesh/stack/src/: mesh_stack.c
  group GATT
    ../Mesh_SDK/mesh/gatt/src/: mesh_gatt.c proxy.c proxy_filter.c
  group Access
    ../Mesh_SDK/mesh/access/src/: access.c access_loopback.c access_publish.c access_publish_retransmission.c access_reliable.c device_state_manager.c
  group Bearer
    ../Mesh_SDK/mesh/bearer/src/: ad_listener.c ad_type_filter.c adv_packet_filter.c advertiser.c bearer_handler.c broadcast.c filter_engine.c gap_address_filter.c mesh_pa_lna.c radio_config.c rssi_filter.c scanner.c
  group Segger RTT
    ../Mesh_SDK/external/rtt/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group uECC
    ../Mesh_SDK/external/micro-ecc/: uECC.c
  group nRF5 SDK
    ../nRF52_SDK_15.2/components/libraries/pwm/: app_pwm.c
    ../nRF52_SDK_15.2/components/libraries/util/: app_error.c app_error_handler_keil.c app_util_platform.c
    ../nRF52_SDK_15.2/components/libraries/atomic/: nrf_atomic.c
    ../nRF52_SDK_15.2/modules/nrfx/drivers/src/: nrfx_ppi.c nrfx_timer.c nrfx_uarte.c nrfx_gpiote.c
    ../nRF52_SDK_15.2/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../nRF52_SDK_15.2/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF52_SDK_15.2/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
    ../nRF52_SDK_15.2/integration/nrfx/legacy/: nrf_drv_ppi.c
  group Provisiong
    ../Mesh_SDK/mesh/prov/src/: nrf_mesh_prov.c nrf_mesh_prov_bearer_gatt.c prov_beacon.c prov_bearer_adv.c prov_provisionee.c prov_utils.c provisioning.c
  group Configuration Model
    ../Mesh_SDK/models/foundation/config/src/: composition_data.c config_server.c packed_index_list.c
  group Health Model
    ../Mesh_SDK/models/foundation/health/src/: health_server.c
  group Other
    ../Mesh_SDK/models/model_spec/generic_level/src/: generic_level_server.c
    ../Mesh_SDK/models/model_spec/common/src/: model_common.c
    ../Mesh_SDK/external/app_timer/: app_timer_mesh.c
software components: CMSIS:CORE 5.1.2, Device:Startup 8.24.1
